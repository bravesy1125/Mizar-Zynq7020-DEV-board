SRC_URI += "file://user_2022-05-22-10-34-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

